** sch_path: xschem/onetops/comp_rc.sch
**.subckt comp_rc a b
*.iopin a
*.iopin b
Rz a n1 1 m=1
Cc n1 b 4p m=1
**.ends
.end
