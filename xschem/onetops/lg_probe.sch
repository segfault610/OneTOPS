** sch_path: xschem/onetops/lg_probe.sch
**.subckt lg_probe drv lin
*.iopin drv
*.iopin lin
Vbrk lin drv dc 0 ac 0
Iinj 0 lin dc 0 ac 0
**.ends
.end
